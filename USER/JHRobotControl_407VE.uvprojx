# Keil uVision project JHRobotControl_407VE.uvprojx, settings and files
target JHRobotControl_407VE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: JHRobotControl_407VE +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\FWLIB\inc;..\DRIVER;..\MOTION_CONTROL;..\STATUS_CONTROL;..\EtherCAT\comm;..\CANopen;..\EtherCAT\EtherCAT_APP;..\EtherCAT\LAN8742A;..\EtherCAT\NetAPP;..\EtherCAT\soem;..\EtherCAT\systick
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c TIM6_USART1_IRQ.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group DRIVER
    ../DRIVER/: Delay.c in.c out.c spi.c w25qxx.c MotorInit.c can.c stmflash.c
  group STATUS_CONTROL
    ../STATUS_CONTROL/: Auto.c Auto_2.c BackToOrigin.c Error.c Manual.c SignalWatch.c StatusControl.c MD.c
  group MOTION_CONTROL
    ../MOTION_CONTROL/: ActionOperate.c JDZ.c Parameter.c SpeedControl.c Usart.c ExtendCom.c DragTeach.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_tim.c
  group CANOPEN
    ../CANopen/: CANopen.c NMT.c PDO.c SDO.c
  group ETHERCAT_APP
    ../EtherCAT/EtherCAT_APP/: EtherCAT_App.c
    ../EtherCAT/LAN8742A/: LAN8742A.c stm32f429_eth.c
    ../EtherCAT/NetAPP/: netconf.c
    ../EtherCAT/systick/: bsp_SysTick.c
  group SOEM
    ../EtherCAT/soem/: ethercatbase.c ethercatcoe.c ethercatconfig.c ethercatdc.c ethercatfoe.c ethercatmain.c ethercatsoe.c nicdrv.c
  group COMM
    ../EtherCAT/comm/: crc16.c cycle_queue.c
target OutBin (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: JHRobotControl_407VE +hex
  AfterMake: fromelf.exe --bin  -o  ..\Obj\M_V1_0.bin ..\Obj\JHRobotControl_407VE.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,BootloaderMode
  c include: as above
  memory RVCT4: ROM 0x8010000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
